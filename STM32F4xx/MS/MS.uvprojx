# Keil uVision project MS.uvprojx, settings and files
target 376.1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MS376
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\MS376.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --i32 -o D:\obj\HEX\ D:\obj\MS376.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MS,MainProtocol=376
  c include: ..\Head;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\Network\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\emWin\Include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.8.0\CMSIS\Driver
  asm define: MainProtocol=376
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\MS376.sct
  group Linker
    ./: MS376.sct MS698.sct MScsg.sct
  group STM32F4xx
    ../STM32F4xx/: STM32F4xx_RCC.c STM32F4xx_SoftDelay.c STM32F4xx_IO.c STM32F4xx_FLASH.c STM32F4xx_TIM.c STM32F4xx_WDG.c STM32F4xx_RTC.c STM32F4xx_CRC.c STM32F4xx_ECC.c STM32F4xx_EXTI.c STM32F4xx_ADC.c STM32F4xx_UART.c STM32F4xx_DMA.c STM32F4xx_SPI.c STM32F4xx_MAC.c STM32F4xx_DAC.c STM32F4xx_DCMI.c STM32F4xx_LTDC.c STM32F4xx_DSIHOST.c STM32F4xx_PWR.c
  group Device
    ./: 设计笔记.txt
    ../Device/: NAND.c MEMRW.c DMW.c IO_I2C.c RTC.c 24AA02E48.c Button.c IC_BUZZ.c IC_TESAM.c LAN8720A.c
  group Display
    ../Display/: LCDDot.c LCDModule.c Display.c Warning.c
    ../Font/: ASCII16FontLib.s smWin_SelfFont.s
  group Calculate
    ../Calculate/: Calculate.c ascii.c
  group Extern OS
    ../OS/: OS.c
    ../emWin/: emWin.c
  group Export MS
    ./: MS_Lable.c
  group Main
    ./: MS_main.c MS_Init.c MS_VER.c MS_ISR.c MS_ISR_ASM.c Data_Save.c MS_SetInitLib.c SetInit.c msFILE.c
    ../OS/: My_Heap.c
  group Thread
    ./: Main_Thread.c Time_Thread.c
  group Updata
    ./: SoftwareCheck.c SoftwareUpdate.c
  group APP
    ./: FSApp.c USB0App.c WAVApp.c MP3App.c
    ../emWin/: emWinApp.c
  group TEST
    ../TEST/: Test_RAM.c TestReport.c LOG.c
    ../Device/: Device_FastTest.c
  group End
    ./: MS_End.s
target 698.45 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: MS698
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\MS698.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --i32 -o D:\obj\HEX\ D:\obj\MS698.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698
  c include: ..\H698;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\Network\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\emWin\Include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.8.0\CMSIS\Driver
  asm define: MainProtocol=698
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\MS698.sct
target CSG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: MScsg
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\MScsg.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --i32 -o D:\obj\HEX\ D:\obj\MScsg.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=CSG
  c include: ..\Hcsg;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\Network\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\emWin\Include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.8.0\CMSIS\Driver
  asm define: MainProtocol=645
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\MScsg.sct
software components: CMSIS:CORE 5.0.0, Device:Startup 2.5.0
