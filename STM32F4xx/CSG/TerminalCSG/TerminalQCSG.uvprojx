# Keil uVision project TerminalQCSG.uvprojx, settings and files
target SouthElectricFK (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TerminalCSG
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\TerminalCSG.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: SE_FK_PROJECT=1,MainProtocol=CSG
  c include: ..\Hcsg;..\TerminalCSG;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\Network\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\emWin\Include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.8.0\CMSIS\Driver;..\QCSG_Head;..\QCSG_Uart;..\QCSG_Task;..\QCSG_Data;..\QCSG_Control;..\QCSG_AlarmEvent
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Terminal.sct
  group Linker
    ./: Terminal.sct Terminal_II.sct
  group Entry
    ./: Terminal_Entry.s
  group LIB
    ../LIB/: Ethernet.c
    D:/obj/: STM32F4xxLIB_CSG.lib
  group Display
    ../Display/: Display.c DisplayLoop_ICO.c DisplayError.c DisplayFlash.c DisplayFTP.c DisplayLoop.c DisplayLoop_ACSample.c DisplayLoop_Contrl.c DisplayLoop_Info.c DisplayLoop_Self.c DisplayLoop_Warning.c Draw.c Warning.c
  group Calculate
    ../Calculate/: Calculate.c ASMCalculate.c DataConversion.c ascii.c
  group Terminal
    ./: Terminal_Main.c Terminal_Init.c Terminal_Init_COM.c Terminal_VER.c Terminal_ISR.c Terminal_Timer.c Terminal_PowerDown.c Terminal_Task.c
    ../TEST/: Test_RAM.c
  group GPRS
    ../GPRS/: ATString.c GPRS_FTP_RxTx.c GPRS_QCSG.c GPRS_SMS_RxTx.c
  group Hcsg
    ../Hcsg/: type.h cmsis_os.h core_cm4.h core_cmFunc.h core_cmInstr.h core_cmSimd.h EFLASH_MeterCSG.h EFLASH_TerminalCSG.h EFLASHCSG.h ERAMCSG.h FLASH_QCSG_SET.h FLASH_QCSG_DATA.h IEEPROMCSG.h IRAM_MeterCSG.h IRAM_MeterSaveCSG.h IRAM_TerminalCSG.h IRAM_TerminalDisplayCSG.h IRAM_TerminalSaveCSG.h IRAMCSG.h Pin_ProjectCSG_2xx.h Pin_ProjectCSG_3xx.h ProjectCSG.h ProjectCSG_2xx_USER0xx.h ProjectCSG_2xx_USER30xx.h ProjectCSG_3xx_USER0xx.h ProjectCSG_3xx_USER30xx.h ERAM_For_Mxn.h ERAM_For_LinYun.h ProjectCSG_3xx_USER34xx.h
  group QCSG_Uart
    ../QCSG_Uart/: UartAuto_645.c Terminal_ReadMeter_ACSample.c TerminalQCSG_Uart_Manage.c
  group QCSG_Task
    ../QCSG_Task/: QCSG_AFN0A.c QCSG_AFN0C.c QCSG_AFN0D.c QCSG_AFN0E.c QCSG_AFN0F.c QCSG_AFN04.c QCSG_AFN10.c QCSG_AFN12.c QCSG_AFN13.c QCSG_Hal.c QCSG_PublicFunc.c QCSG_Resolve.c QCSG_Table.c ReadMeter_Task.c CH_PLC_AMR_Task.c CH_RS485_AMR_Task.c CH_AMR_TaskManage.c CH_RS485_AMS_Task.c QCSG_AFN15.c
  group QCSG_Control
    ../QCSG_Control/: QCSG_Ctrl.c
  group QCSG_Head
    ../QCSG_Head/: QCSG_UpLinkProtocol.h Chint_Type.h QCSG_AFN0A.h QCSG_AFN0C.h QCSG_AFN0D.h QCSG_AFN0E.h QCSG_AFN0F.h QCSG_AFN04.h QCSG_AFN10.h QCSG_AFN12.h QCSG_AFN13.h QCSG_DLT645_Protocol.h QCSG_Hal.h QCSG_PublicDefine.h QCSG_PublicFunc.h QCSG_Resolve.h QCSG_Table.h ReadMeter_Task.h CH_RS485_AMS_Task.h QCSG_AFN15.h
  group QCSG_Data
    ../QCSG_Data/: QCSG_NandDataInterface.c QCSG_DefaultData.c
  group QCSG_AlramEvent
    ../QCSG_AlarmEvent/: QCSG_AlarmEvent.c
  group End
    ./: Terminal_End.s
target SouthElectricJZQ (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: Terminal_JZQ_QCSG
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --i32 -o D:\workspace\Terminal_obj\Terminal_JZQ\HEX\Terminal_JZQ_QCSG.hex D:\workspace\Terminal_obj\Terminal_JZQ\Terminal_JZQ_QCSG.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\workspace\Terminal_obj\Terminal_JZQ\BIN\Terminal_JZQ_QCSG.bin D:\workspace\Terminal_obj\Terminal_JZQ\Terminal_JZQ_QCSG.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: SE_JZQ_PROJECT=1,MainProtocol=CSG
  c include: ..\Hcsg;..\Terminal;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.4.1\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.4.1\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.4.1\Network\Include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.11.0\CMSIS\Driver;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.4.1\emWin\Include;..\QCSG_Head;..\QCSG_Uart;..\QCSG_Task;..\QCSG_Data;..\QCSG_Control;..\QCSG_AlarmEvent
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Terminal.sct
target SouthElectricJZQ_II (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: Terminal_II_JZQ_QCSG
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --i32 -o D:\workspace\Terminal_obj\Terminal_II_JZQ\HEX\Terminal_II_JZQ_QCSG.hex D:\workspace\Terminal_obj\Terminal_II_JZQ\Terminal_II_JZQ_QCSG.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\workspace\Terminal_obj\Terminal_II_JZQ\BIN\Terminal_II_JZQ_QCSG.bin D:\workspace\Terminal_obj\Terminal_II_JZQ\Terminal_II_JZQ_QCSG.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: SE_JZQ_II_PROJECT=1,MainProtocol=CSG
  c include: ..\Hcsg;..\Terminal;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.4.1\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.4.1\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.4.1\Network\Include;C:\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\2.11.0\CMSIS\Driver;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.4.1\emWin\Include;..\QCSG_Head;..\QCSG_Uart;..\QCSG_Task;..\QCSG_Data;..\QCSG_Control;..\QCSG_AlarmEvent
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Terminal_II.sct
target SouthElectricPB (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: Terminal_JZQ_QCSG
  AfterMake: as above
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: SE_PB_PROJECT=1,MainProtocol=CSG
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Terminal.sct
software components: CMSIS:CORE 5.0.1, Device:STM32Cube Framework:Classic 1.7.4, Device:STM32Cube HAL:Common 1.6.0, Device:STM32Cube HAL:Cortex 1.6.0, Device:STM32Cube HAL:DMA 1.6.0, Device:STM32Cube HAL:GPIO 1.6.0, Device:STM32Cube HAL:NAND 1.6.0, Device:STM32Cube HAL:PWR 1.6.0, Device:STM32Cube HAL:RCC 1.6.0, Device:STM32Cube HAL:SDRAM 1.6.0
