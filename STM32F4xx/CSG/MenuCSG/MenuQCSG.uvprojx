# Keil uVision project MenuQCSG.uvprojx, settings and files
target Menu_FK_QCSG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: MenuCSG
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\MenuCSG.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: SE_FK_PROJECT=1
  c include: ..\Hcsg;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\Network\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\emWin\Include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.8.0\CMSIS\Driver;..\QCSG_Head;..\QCSG_Data;..\QCSG_Task
  memory RVCT4: ROM 0x81c0000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Menu.sct
  group Linker
    ./: Menu.sct
  group Entry
    ./: Menu_Entry.s
  group LIB
    D:/obj/: STM32F4xxLIB_CSG.lib
  group Display
    ../Display/: Display.c Draw.c DisplayLoop.c DisplayLoop_Warning.c DisplayLoop_ICO.c DisplayLoop_ACSample.c Warning.c
    ../QCSG_Uart/: Terminal_ReadMeter_ACSample.c
  group Calculate
    ../Calculate/: Calculate.c DataConversion.c ascii.c
  group Main
    ./: Menu.c Menu_Main.c Menu_Init.c Menu_VER.c
  group Menu
    ./: Menu_1_RealTimeData.c Menu_2_PowerCalculation.c Menu_3_PowerQualityMonitoring.c Menu_4_PowerOffStatistics.c Menu_5_EventRecord.c Menu_6_AbnormalAlarm.c Menu_7_ParametersSetting.c Menu_8_TerminalManagement.c
  group QCSG_Data
    ../QCSG_Task/: QCSG_PublicFunc.c QCSG_Table.c QCSG_Hal.c
    ../QCSG_Data/: QCSG_NandDataInterface.c QCSG_DefaultData.c
  group End
    ./: Menu_End.s
  group QCSG_Head
    ../QCSG_Head/: QCSG_PublicDefine.h QCSG_PublicFunc.h QCSG_UpLinkProtocol.h QCSG_Table.h QCSG_DLT645_Protocol.h
target Menu_JZQ_QCSG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: Menu_JZQ_QCSG
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --i32 -o D:\workspace\Terminal_obj\Menu_JZQ\HEX\Menu_JZQ_QCSG.hex D:\workspace\Terminal_obj\Menu_JZQ\Menu_JZQ_QCSG.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\workspace\Terminal_obj\Menu_JZQ\BIN\Menu_JZQ_QCSG.bin D:\workspace\Terminal_obj\Menu_JZQ\Menu_JZQ_QCSG.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: SE_JZQ_PROJECT=1
  c include: as above
  memory RVCT4: ROM 0x81c0000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Menu.sct
target Menu_PB_QCSG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: Menu_PB_QCSG
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --i32 -o D:\workspace\Terminal_obj\Menu_PB\HEX\Menu_PB_QCSG.hex D:\workspace\Terminal_obj\Menu_PB\Menu_PB_QCSG.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\workspace\Terminal_obj\Menu_PB\BIN\Menu_PB_QCSG.bin D:\workspace\Terminal_obj\Menu_PB\Menu_PB_QCSG.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: SE_PB_PROJECT=1
  c include: ..\Hcsg;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.4.1\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.4.1\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.4.1\Network\Include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.11.0\CMSIS\Driver;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.4.1\emWin\Include;..\QCSG_Head;..\QCSG_Data;..\QCSG_Task
  memory RVCT4: ROM 0x81c0000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Menu.sct
software components: CMSIS:CORE 5.0.2
