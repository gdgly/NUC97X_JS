# Keil uVision project STM32F4xxLIB.uvprojx, settings and files
target 376.1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x50000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: STM32F4xxLIB_376 (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=376
  c include: C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Network_DS\0.10.0\Network_DS\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\emWin\Include;..\Head
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group STM32F4xx
    ../STM32F4xx/: STM32F4xx_ADC.c STM32F4xx_CRC.c STM32F4xx_DAC.c STM32F4xx_DMA.c STM32F4xx_ECC.c STM32F4xx_EXTI.c STM32F4xx_FLASH.c STM32F4xx_FMC.c STM32F4xx_IO.c STM32F4xx_MAC.c STM32F4xx_PWR.c STM32F4xx_RCC.c STM32F4xx_RCC_Config.c STM32F4xx_RTC.c STM32F4xx_SoftDelay.c STM32F4xx_SPI.c STM32F4xx_TIM.c STM32F4xx_UART.c STM32F4xx_WDG.c STM32F4xx_ExtMem.c
  group Device
    ../Device/: extern_MRW.c NAND.c IO_I2C.c RTC.c 24AA02E48.c Button.c IC_BUZZ.c IC_TESAM.c LAN8720A.c ATM90E36.c MESAM.c PCF8562.c IC_CARD.c
  group OS
    ../OS/: OS.c My_Heap.c OS_Event.c
    ../MS/: FSApp.c msFILE.c Ethernet.c
    ../TEST/: LOG.c
    ../emWin/: emWin.c emWinApp.c
  group MS
    ../MS/: MS.c Data_Save.c
  group ACTION
    ../DL698/: DL698_DataDef.c
  group USER
    ../Terminal/: Terminal_USER11xx.c
target 698.45 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: STM32F4xxLIB_698 (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698
  c include: ..\H698;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Network_DS\0.10.0\Network_DS\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\emWin\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
target CSG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: STM32F4xxLIB_CSG (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=CSG
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
software components: CMSIS:CORE 5.0.0, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:NAND 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:SDRAM 1.5.0
