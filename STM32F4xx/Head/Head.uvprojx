# Keil uVision project Head.uvprojx, settings and files
target 376.1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Head
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\Head
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group 方案2:Ⅰ型集中器
    ./: Project2xx_USER0xx.h Project2xx_USER8xx.h Project2xx_USER9xx.h Project2xx_USER11xx.h Project2xx_USER12xx.h Project2xx_USER14xx.h Pin_Project2xx.h
  group 方案3:Ⅲ型专变终端
    ./: Project3xx_USER0xx.h Project3xx_USER5xx.h Project3xx_USER8xx.h Project3xx_USER12xx.h Pin_Project3xx.h
  group 公有
    ./: Project.h type.h IRAM.h EFLASH.h IEEPROM.h
  group Meter
    ./: IRAM_Meter.h IRAM_MeterSave.h EFLASH_Meter.h
  group Terminal
    ./: IRAM_Terminal.h IRAM_TerminalDisplay.h IRAM_TerminalSave.h ERAM.h EFLASH_Terminal.h AFN04MaxPn.h AFN05MaxPn.h AFN0CMaxPn.h AFN0DMaxPn.h AFN0DMaxPn_Project0xx.h AFN0DMaxPn_Project1xx.h AFN0DMaxPn_Project2xx.h AFN0DMaxPn_Project3xx.h AFN0DMaxPn_Project4xx.h AFN0DMaxPn_Project5xx.h AFN0DMaxPn_Project6xx.h AFN04.h AFN05.h AFN0C.h AFN0C_HourCongeal.h AFN0C_HourCongeal_Buff.h AFN0D.h AFN0D_Congeal_Buff.h AFN0D_Source.h AFN0E.h
