# Keil uVision project Menu698.uvprojx, settings and files
target 698.45 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Menu698
  AfterMake: E:\Keil\ARM\ARMCC\bin\fromelf.exe --i32 -o D:\obj\HEX\ D:\obj\Menu698.axf
  AfterMake: E:\Keil\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\Menu698.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: MainProtocol=698
  c include: ..\H698;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\Network\Include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.8.0\CMSIS\Driver
  asm define: MainProtocol=698
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Menu.sct
  group Linker
    ./: Menu.sct
  group Entry
    ./: Menu_Entry.s
  group LIB
    D:/obj/: STM32F4xxLIB_698.lib
    ../DL698/: Get_RM_Record.c
  group Display
    ../Display/: Display.c Draw.c
  group Calculate
    ../Calculate/: Calculate.c DataConversion.c ascii.c
  group Main
    ./: Menu_Main.c Menu_Init.c Menu_VER.c
  group Menu
    ./: Menu.c Menu_1_RealTimeData.c Menu_2_Parameters.c Menu_2_ParametersSetting.c Menu_3_ControlState.c Menu_3_SystemManagement.c Menu_4_MeterData.c Menu_5_ChineseNews.c Menu_6_PowerPurchase .c Menu_7_TerminalInformation.c
  group End
    ./: Menu_End.s
