# Keil uVision project Hcsg.uvprojx, settings and files
target CSG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x50000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: H698
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group 方案CSG:2 Ⅰ型集中器
    ./: ProjectCSG_2xx_USER30xx.h Pin_ProjectCSG_2xx.h
  group 方案CSG:3 Ⅲ型专变终端
    ./: ProjectCSG_3xx_USER30xx.h ProjectCSG_3xx_USER34xx.h Pin_ProjectCSG_3xx.h
  group 方案CSG:5 Ⅱ型集中器
    ./: ProjectCSG_5xx_USER30xx.h Pin_ProjectCSG_5xx.h
    ../H698/: PinNUC97x_Project698_5xx.h
  group 公有CSG
    ./: ProjectCSG.h IRAMCSG.h EFLASHCSG.h IEEPROMCSG.h ERAMCSG.h FLASH_DLCSG_SET.h FLASH_DLCSG_DATA.h FLASH_QCSG_SET.h
  group MeterCSG
    ./: IRAM_MeterCSG.h IRAM_MeterSaveCSG.h EFLASH_MeterCSG.h
  group TerminalCSG
    ./: IRAM_TerminalCSG.h IRAM_TerminalDisplayCSG.h IRAM_TerminalSaveCSG.h EFLASH_TerminalCSG.h
