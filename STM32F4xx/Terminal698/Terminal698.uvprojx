# Keil uVision project Terminal698.uvprojx, settings and files
target 698.45 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Terminal698
  AfterMake: E:\CHINT_WORK\Keil-5-22\ARM\ARMCC\bin\fromelf.exe --i32 -o D:\obj\HEX\ D:\obj\Terminal698.axf
  AfterMake: E:\CHINT_WORK\Keil-5-22\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\Terminal698.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: MainProtocol=698
  c include: ..\H698;D:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\USB\Include;D:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\FileSystem\Include;D:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\Network\Include;D:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.8.0\CMSIS\Driver;D:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\emWin\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Terminal.sct
  group Linker
    ./: Terminal.sct
  group Entry
    ./: Terminal_Entry.s
  group LIB
    ../../: STM32F4xxLIB_698.lib
    ../MS/: Ethernet.c
  group Display
    ../Display/: Display.c DisplayLoop_ICO.c DisplayError.c DisplayFlash.c DisplayFTP.c DisplayLoop.c DisplayLoop_ACSample.c DisplayLoop_Info.c DisplayLoop_Self.c DisplayLoop_Warning.c Draw.c Warning.c
    ../DL698/: DL698_DisplayLoop_Contrl.c
  group Calculate
    ../Calculate/: Calculate.c ASMCalculate.c DataConversion.c ascii.c
  group Main
    ./: Terminal_Main.c Terminal_Init.c Terminal_VER.c Terminal_ISR.c Terminal_Timer.c Terminal_PowerDown.c
    ../MS/: SetInit.c MS_ISR_ASM.c
    ../TEST/: LOG.c Test_RAM.c TestReport.c
  group GPRS
    ../Device/: ATNo.h GPRS_3763.c GPRS_SMS_RxTx.c GPRS_FTP_RxTx.c
    ./: ATString.c
  group UART Manage
    ./: Terminal698_Uart_Manage.c UartAuto_645.c Terminal_ReadMeter_ACSample.c
  group DL698_UART
    ../DL698/: 帧结构.txt DL698_DataDef.c DL698_OI_IC.c DL698_TESAM.c DL698_UART.cpp DL698_LINK.cpp DL698_CONNECT.cpp DL698_ConnectAppOI.c DL698_SECURITY.c DL698_TIMETAG.c DL698_GET.cpp DL698_GET_iMeterLIB.c DL698_GET_iMeter.c DL698_DATALIB.c DL698_DATALIB_2000.c DL698_GET_EVENT.cpp DL698_GET_4100.c DL698_GET_6000.cpp DL698_GET_F000.cpp DL698_GET_RECORD.c DL698_SETLIB.c DL698_SETLIB_2000.c DL698_SETLIB_EVENT.c DL698_SETLIB_4000.c DL698_SETLIB_5000.c DL698_SETLIB_6000.c DL698_SETLIB_8000.c DL698_SETLIB_F000.c DL698_SET.cpp DL698_SET_EVENT.cpp DL698_SET_6000.cpp DL698_ACTION.cpp DL698_ACTION_EVENT.cpp DL698_ACTION_4000.cpp DL698_ACTION_5000.c DL698_ACTION_6000.cpp DL698_ACTION_8000.cpp DL698_ACTION_F000.cpp DL698_GET_SET_ACTION_2000.c DL698_PROXY.c DL698_REPORT.c DL698_FILE.c DL698_FactoryTest.c
  group USER0
    ../DL698/: DL698_SETInit_USER0xx.c DL698_SETInit_Event_USER0xx.c DL698_SETInit_6000_Project2xx_USER0xx.c DL698_SETInit_6000_Project3xx_USER0xx.c
  group USER9xx
    ../DL698/: DL698_SETInit_USER9xx.c DL698_SETInit_Event_USER9xx.c DL698_SETInit_6000_Project2xx_USER9xx.c
  group USER14xx
    ../DL698/: DL698_SETInit_USER14xx.c DL698_SETInit_Event_USER14xx.c DL698_SETInit_6000_Project2xx_USER14xx.c DL698_ACTION_USER14xx.c
  group USER15xx
    ../DL698/: DL698_SETInit_USER15xx.c DL698_SETInit_Event_USER15xx.c DL698_SETInit_6000_Project3xx_USER15xx.c
  group USER16xx
    ../DL698/: DL698_SETInit_USER16xx.c DL698_SETInit_Event_USER16xx.c DL698_SETInit_6000_Project4xx_USER16xx.c
  group USER17xx
    ../DL698/: DL698_SETInit_6000_Project2xx_USER17xx.c DL698_SETInit_Event_USER17xx.c DL698_SETInit_USER17xx.c
  group RM_TASK
    ../DL698/: DL698_SETInit_601E.c TASK.cpp RM_TASK.cpp RM_TASK_USERxxx.c RM_RS485_Manage.cpp RM_RS485.c RM_3762_Manage.c RM_3762.c Uart_3762_RxTx.c RM_3762_RouterActive.c RM_3762_iActive.c RM_3762_iActive_HPLC.c Info_3762.c RM_TxDATA.c RM_TxDATA_DL1997.cpp RM_TxDATA_DL2007.cpp RM_TxDATA_DL698.cpp RM_TxDATA_ABB.c RM_TxDATA_Landis.c RM_RxDATA.cpp RM_RxDATA_DL1997.cpp RM_RxDATA_DL2007.cpp RM_RxDATA_DL698.cpp RM_RxDATA_ABB.c RM_RxDATA_Landis.c
  group OTHER_TASK
    ../DL698/: PROXY_TASK.c BroadcastTime.c MeterAutoReport.c AutoSearchMeter_3762.c AutoSearchMeter_RS485.c
  group FILE
    ../DL698/: 文件存储格式与使用注意.txt RM_Record.cpp Get_RM_Record.c EVENT_Record.c CONGEAL_Record.c SearchMeter_Record.c MeterAutoReport_Record.c
  group EVENT
    ../DL698/: EVENT_CALC.c EVENT_CALC_iMeter.c RM_Event_DL2007.c
  group DATA
    ../DL698/: CALC_SwitchIn.c CALC_RESET_FLOW_TIME.c CALC_Voltage_Qualification_Rate.c CALC_impIn.c CALC_TAG.c
  group CONTRL
    ../DL698/: Contrl_Manage.c Contrl_Uart.c Contrl_Remote.c Contrl_Power.c Contrl_Energy.c Contrl_Out.c Contrl_State.c
  group TEST
    ../DL698/: DL698TEST_1.c DL698TEST_USER9xx.c
  group End
    ./: Terminal_End.s
software components: CMSIS:CORE 5.1.1, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:SDRAM 1.5.0
