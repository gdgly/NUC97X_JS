# Keil uVision project H698.uvprojx, settings and files
target 698.45 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x50000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: H698
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group 方案698:2 Ⅰ型集中器
    ./: Project698_2xx_USER0xx.h Project698_2xx_USER9xx.h Project698_2xx_USER14xx.h Project698_2xx_USER17xx.h Pin_Project698_2xx.h PinNUC97x_Project698_2xx.h
  group 方案698:3 Ⅲ型专变终端
    ./: Project698_3xx_USER0xx.h Project698_3xx_USER12xx.h Project698_3xx_USER15xx.h Pin_Project698_3xx.h PinNUC97x_Project698_3xx.h
  group 方案698:4 三合一终端
    ./: Project698_4xx_USER16xx.h Pin_Project698_4xx.h PinNUC97x_Project698_4xx.h
  group 方案698:5 Ⅱ型集中器
    ./: Project698_5xx_USER0xx.h PinNUC97x_Project698_5xx.h
  group 公有698
    ./: Project698.h type.h IRAM698.h EFLASH698.h IEEPROM698.h ERAM698.h FLASH_DL698_SET.h FLASH_DL698_DATA.h
  group Meter698
    ./: IRAM_Meter698.h IRAM_MeterSave698.h EFLASH_Meter698.h
  group Terminal698
    ./: IRAM_Terminal698.h IRAM_TerminalDisplay698.h IRAM_TerminalSave698.h EFLASH_Terminal698.h
