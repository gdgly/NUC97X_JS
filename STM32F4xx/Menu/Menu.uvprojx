# Keil uVision project Menu.uvprojx, settings and files
target 376.1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Menu
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --i32 -o D:\obj\HEX\ D:\obj\Menu.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\Menu.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: MainProtocol=376
  c include: ..\Head;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\Network\Include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.8.0\CMSIS\Driver;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\emWin\Include
  asm define: MainProtocol=376
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Menu.sct
  group Linker
    ./: Menu.sct
  group Entry
    ./: Menu_Entry.s
  group LIB
    D:/obj/: STM32F4xxLIB_376.lib
  group Display
    ../Display/: Display.c Draw.c
  group Calculate
    ../Calculate/: Calculate.c DataConversion.c ascii.c
  group Main
    ./: Menu_Main.c Menu_Init.c Menu_VER.c
  group Menu
    ./: Menu.c Menu_1_RealTimeData.c Menu_2_Parameters.c Menu_3_ControlState.c Menu_4_MeterData.c Menu_5_ChineseNews.c Menu_6_PowerPurchase .c Menu_7_TerminalInformation.c Menu_8_ParametersSetting.c Menu_9_SystemManagement.c
  group Data
    ../Terminal/: Terminal_AFN0C_RealTimeData_Lib.c Terminal_AFN0C_RealTimeData_Fn.c Terminal_AFN0C_RealTimeData_Init.c Terminal_AFN0D_CongealData_Lib.c Terminal_AFN0D_CongealData_Fn.c Terminal_AFN0D_CongealData_Init.c Terminal_AFN0D_SourceData_Lib.c Terminal_AFN0D_SourceData_Fn.c Terminal_AFN0D_SourceData_Init.c
  group Other
    ../Terminal/: KeyUser.c Terminal_AFN04_Paramter_Check.c
  group End
    ./: Menu_End.s
