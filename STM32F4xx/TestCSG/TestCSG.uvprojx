# Keil uVision project TestCSG.uvprojx, settings and files
target CSG (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IRAM(0x20000000,0x50000) IROM(0x08000000,0x200000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TestCSG
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --i32 -o D:\obj\HEX\ D:\obj\TestCSG.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\TestCSG.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=CSG
  c include: ..\Head;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\Network\Include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.8.0\CMSIS\Driver;C:\Keil_v5\ARM\Pack\Keil\STM32F4xx_DFP\2.8.0\Drivers\STM32F4xx_HAL_Driver
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\TestCSG.sct
  group Linker
    ./: TestCSG.sct
  group Entry
    ./: Test_Entry.s
  group Lib
    ./: TEST.lib
  group Main
    ./: Test_Main.c Test_Init.c Test_VER.c TestReport.c
  group TEST
    ./: Test.c Test_RAM.c Test_POWER.c Test_STM32F4xx.c Test_MT29FxG_NAND.c Test_S34MLxG_NAND.c Test_FLASH_Block_Err.c Test_FLASH_Life.c Test_90E36.c Test_RTC.c Test_LAN8720A.c Test_UART.c Test_ETH.c Test_GPRS.c Test_LOCAL_MODULE.c Test_CONTRL_MODULE.c Test_ESAM.c Test_24AA02E48.c Test_INOUT.c Test_KEY_LED_BUZZER.c LOG.c
  group End
    ./: Test_End.s
software components: CMSIS:CORE 5.0.2, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:ADC 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:ETH 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:NAND 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:SDRAM 1.5.0
