# Keil uVision project TEST.uvprojx, settings and files
target 376.1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: TEST
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --i32 -o D:\obj\HEX\ D:\obj\TEST.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\TEST.axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=376
  c include: ..\Head;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\Network\Include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.8.0\CMSIS\Driver
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Test376.sct
  group Linker
    ./: Test376.sct Test698.sct TestCSG.sct
  group Entry
    ./: Test_Entry.s
  group STM32F4xx
    ../STM32F4xx/: STM32F4xx_RCC.c STM32F4xx_RCC_Config.c STM32F4xx_SoftDelay.c STM32F4xx_IO.c STM32F4xx_ECC.c STM32F4xx_TIM.c STM32F4xx_WDG.c STM32F4xx_CRC.c STM32F4xx_SPI.c STM32F4xx_UART.c STM32F4xx_DMA.c STM32F4xx_ADC.c STM32F4xx_MAC.c STM32F4xx_RTC.c STM32F4xx_EXTI.c
    ../MS/: Data_Save.c
  group Device
    ../Device/: extern_MRW.c NAND.c IO_I2C.c RTC.c 24AA02E48.c Button.c IC_BUZZ.c IC_TESAM.c LAN8720A.c
  group Extern OS
    ../OS/: OS.c My_Heap.c
    ../MS/: FSApp.c MS.c
  group Display
    ../Display/: Display.c Draw.c
  group Calculate
    ../Calculate/: Calculate.c ascii.c
  group Menu
    ../Menu/: Menu.c
  group Main
    ./: Test_Main.c Test_Init.c Test_VER.c TestReport.c
  group TEST
    ./: Test.c Test_RAM.c Test_POWER.c Test_STM32F4xx.c Test_SDRAM.c Test_MT29FxG_NAND.c Test_S34MLxG_NAND.c Test_FLASH_Block_Err.c Test_FLASH_Life.c Test_90E36.c Test_RTC.c Test_LAN8720A.c Test_UART.c Test_ETH.c Test_GPRS.c Test_LOCAL_MODULE.c Test_CONTRL_MODULE.c Test_ESAM.c Test_24AA02E48.c Test_INOUT.c Test_KEY_LED_BUZZER.c LOG.c
    ../DL698/: DL698_DataDef.c
  group 3762
    ./: Test_Uart_3762_RxTx.c Test_ReadMeter_3762_376.c Test_ReadMeter_3762_698.c
  group USER
    ../Terminal698/: Terminal_USER11xx.c Terminal_Uart_3761_COM.c
  group End
    ./: Test_End.s
target 698.45 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: TEST
  AfterMake: as above
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Test698.sct
target CSG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: as above
  output: TEST (library)
  AfterMake: as above
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=CSG
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\TestCSG.sct
software components: CMSIS:CORE 5.0.1, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:ETH 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:NAND 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:SDRAM 1.5.0
