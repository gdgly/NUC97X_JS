# Keil uVision project Terminal.uvprojx, settings and files
target 376.1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F469BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.9.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x50000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Terminal
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --i32 -o D:\obj\HEX\ D:\obj\Terminal.axf
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\Terminal.axf
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: Terminal,MainProtocol=376
  c include: ..\Head;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\USB\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\FileSystem\Include;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\Network\Include;C:\Keil_v5\ARM\PACK\Keil\STM32F4xx_DFP\2.8.0\CMSIS\Driver;C:\Keil_v5\ARM\Pack\Keil\MDK-Middleware\7.1.0\emWin\Include
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  scatter file: .\Terminal.sct
  group Linker
    ./: Terminal.sct 修改记录.txt
  group Entry
    ./: Terminal_Entry.s
  group LIB
    D:/obj/: STM32F4xxLIB_376.lib
  group Display
    ../Display/: Display.c DisplayLoop_ICO.c DisplayError.c DisplayFlash.c DisplayFTP.c DisplayLoop.c DisplayLoop_ACSample.c DisplayLoop_Contrl.c DisplayLoop_Info.c DisplayLoop_Self.c DisplayLoop_Warning.c Draw.c Warning.c
  group Calculate
    ../Calculate/: Calculate.c ASMCalculate.c DataConversion.c ascii.c
  group Main
    ./: Terminal_Main.c Terminal_Init.c Terminal_Init_COM.c Terminal_VER.c Terminal_ISR.c Terminal_Timer.c Terminal_PowerDown.c
    ../MS/: SetInit.c
    ../TEST/: Test_RAM.c
  group SetInitLib
    ./: I2_SetInitLib_Project2xx_USER0xx.c I2_SetInitLib_Project2xx_USER4xx.c I2_SetInitLib_Project2xx_USER5xx.c I2_SetInitLib_Project2xx_USER6xx.c I2_SetInitLib_Project2xx_USER601.c I2_SetInitLib_Project2xx_USER7xx.c I2_SetInitLib_Project2xx_USER8xx.c I2_SetInitLib_Project2xx_USER9xx.c I2_SetInitLib_Project2xx_USER11xx.c I2_SetInitLib_Project2xx_USER12xx.c I2_SetInitLib_Project2xx_USER14xx.c I2_SetInitLib_Project3xx_USER0xx.c I2_SetInitLib_Project3xx_USER1xx.c I2_SetInitLib_Project3xx_USER5xx.c I2_SetInitLib_Project3xx_USER8xx.c I2_SetInitLib_Project3xx_USER10xx.c I2_SetInitLib_Project3xx_USER12xx.c I2_SetInitLib_Project3xx_USER13xx.c
  group GPRS
    ../Device/: ATNo.h GPRS_3763.c GPRS_SMS_RxTx.c GPRS_FTP_RxTx.c
    ./: ATString.c
  group UART1376.1
    ./: Terminal_Uart_Manage.c Terminal_Uart_3761.c Terminal_Uart_3761_COM.c Terminal_Uart_AutoEvent.c Terminal_Uart_TimerTask.c Terminal_Uart_Cascading.c Terminal_Uart_AFN00_ACK.c Terminal_Uart_AFN01_Reset.c Terminal_Uart_AFN02_Heartbeat.c Terminal_AFN04_Paramter_Check.c Terminal_AFN04_Paramter_Lib.c Terminal_Uart_AFN04_Paramter.c Terminal_AFN05_Command_Lib.c Terminal_Uart_AFN05_Command.c Terminal_Uart_AFN06_PW.c Terminal_Uart_AFN08_Cascading.c Terminal_Uart_AFN09F1.c Terminal_Uart_AFN09_Configure.c Terminal_Uart_AFN0B_TaskData.c Terminal_Uart_AFN0C_RealTimeData.c Terminal_Uart_AFN0D_CongealData.c Terminal_Uart_AFN0E_EventData.c Terminal_Uart_AFN0F_File.c Terminal_Uart_AFN10_Command.c Terminal_Uart_AFN10_Forwarding.c Terminal_Uart_AFNFF_Test.c Terminal_Uart_AutoAFN0AF299.c UartAuto_645.c
  group ReadMeter(RealTime)
    ./: Terminal_ReadMeter_AFN0C_RealTime.c Terminal_ReadMeter_AFN0D_RealTime.c
  group DATA
    ./: Terminal_AFN0C_RealTimeData_Lib.c Terminal_AFN0C_RealTimeData_Fn.c Terminal_AFN0C_RealTimeData_Init.c Terminal_AFN0C_RealTimeData.c Terminal_AFN0D_CongealData_Lib.c Terminal_AFN0D_CongealData_Fn.c Terminal_AFN0D_CongealData_Init.c Terminal_AFN0D_CongealData.c Terminal_AFN0D_SourceData_Lib.c Terminal_AFN0D_SourceData_Fn.c Terminal_AFN0D_SourceData_Init.c Terminal_AFN0D_SourceData.c Terminal_AFN0E_Event.c Terminal_Statistic.c Terminal_Statistic_E.c Terminal_SwitchIn.c Terminal_impIn.c Average_Voltage.c
  group ERC
    ./: Terminal_AFN0E_Event.h
    ../Head/: ERC_Project1_USER0xx.h ERC_Project2_USER0xx.h ERC_Project2_USER4xx.h ERC_Project2_USER5xx.h ERC_Project2_USER6xx.h ERC_Project2_USER7xx.h ERC_Project2_USER8xx.h ERC_Project2_USER9xx.h ERC_Project2_USER11xx.h ERC_Project2_USER12xx.h ERC_Project3_USER0xx.h ERC_Project3_USER5xx.h ERC_Project3_USER8xx.h ERC_Project3_USER10xx.h ERC_Project3_USER12xx.h ERC_Project4_USER0xx.h
  group Contrl
    ./: Terminal_Contrl_Manage.c Terminal_Contrl_Remote.c Terminal_Contrl_Power.c Terminal_Contrl_Energy.c Terminal_Contrl_Out.c Terminal_Contrl_Uart.c
  group Terminal_ReadMeter_Task
    ./: Terminal_ReadMeter_Fn_Project2xx_USER0xx.c Terminal_ReadMeter_Fn_Project2xx_USER4xx.c Terminal_ReadMeter_Fn_Project2xx_USER5xx.c Terminal_ReadMeter_Fn_Project2xx_USER6xx.c Terminal_ReadMeter_Fn_Project2xx_USER7xx.c Terminal_ReadMeter_Fn_Project2xx_USER8xx.c Terminal_ReadMeter_Fn_Project2xx_USER9xx.c Terminal_ReadMeter_Fn_Project2xx_USER11xx.c Terminal_ReadMeter_Fn_Project2xx_USER12xx.c Terminal_ReadMeter_Fn_Project2xx_USER14xx.c Terminal_ReadMeter_Fn_Project3xx_USER0xx.c Terminal_ReadMeter_Fn_Project3xx_USER5xx.c Terminal_ReadMeter_Fn_Project3xx_USER8xx.c Terminal_ReadMeter_Fn_Project3xx_USER10xx.c Terminal_ReadMeter_Fn_Project3xx_USER12xx.c Terminal_ReadMeter_Fn_Project3xx_USER13xx.c
  group ReadMeter(RS485)
    ./: Terminal_ReadMeter_ACSample.c Terminal_ReadMeter_RS485.c Terminal_ReadMeter_SaveFnData.c Terminal_ReadMeter_CountAndFlag.c Terminal_ReadMeter_DL645.c Terminal_ReadMeter_DL645_2007_Lib.c Terminal_ReadMeter_DL645_2007_FnData.c Terminal_ReadMeter_DL645_2007.c Terminal_ReadMeter_DL645_1997_Lib.c Terminal_ReadMeter_DL645_1997_FnData.c Terminal_ReadMeter_DL645_1997.c Terminal_ReadMeter_Event.c Terminal_ReadMeter_WSH.c Terminal_ReadMeter_WSH41_Lib.c Terminal_ReadMeter_WSH41_FnData.c Terminal_ReadMeter_WSH41.c Terminal_ReadMeter_ShH_Lib.c Terminal_ReadMeter_ShH_FnData.c Terminal_ReadMeter_ShH.c
  group KeyUser
    ./: KeyUser.c
  group ReadMeter(376.2)
    ./: Terminal_uart_3762_Manage.c Terminal_Uart_3762_RxTx.c Terminal_ReadMeter_3762.c Terminal_ReadMeter_3762_Std.c Terminal_ReadMeter_3762_NoRouter.c Terminal_ReadMeter_Note.c Terminal_RouterUpDate.c
  group AutoSearchMeter
    ./: AutoSearchMeter.c AutoSearchMeter_RS485.c AutoSearchMeter_3762.c
  group BatchTask
    ./: BatchTask_RS485.c BatchTask_3762.c
  group USER
    ./: Terminal_USER2xx.c Terminal_USER5xx.c Terminal_USER6xx.c Terminal_USER11xx.c DataConversion_SH698.c Terminal_ReadMeter_DL698.c Terminal_ReadMeter_DL698_FnData.c Terminal_ReadMeter_DL698_Lib.c RouterBroadcastTime_Collector.c Terminal_ReadMeter_HX.c Terminal_ReadMeter_HX_6E.c Terminal_ReadMeter_HX_6E_FnData.c Terminal_ReadMeter_HX_6E_Lib.c Airthmetic.c
  group End
    ./: Terminal_End.s
software components: CMSIS:CORE 5.0.0, Device:STM32Cube Framework:Classic 1.5.0, Device:STM32Cube HAL:Common 1.5.0, Device:STM32Cube HAL:Cortex 1.5.0, Device:STM32Cube HAL:DMA 1.5.0, Device:STM32Cube HAL:GPIO 1.5.0, Device:STM32Cube HAL:NAND 1.5.0, Device:STM32Cube HAL:PWR 1.5.0, Device:STM32Cube HAL:RCC 1.5.0, Device:STM32Cube HAL:SDRAM 1.5.0
