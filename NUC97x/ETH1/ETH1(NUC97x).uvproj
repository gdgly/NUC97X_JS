# Keil uVision project ETH1(NUC97x).uvproj, settings and files
target NUC972 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: ETH1(NUC97x)
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\ETH1(NUC97x).axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698
  c misc: --diag_suppress=1295,177,550,167,68,223,188,1293,61
  c include: ..\Driver\Include;..\OS\lwip-1.4.1\include;..\OS\ThirdParty\lwip-1.4.1\src\include;..\OS\ThirdParty\lwip-1.4.1\src\include\ipv4;..\OS\ThirdParty\lwip-1.4.1\src\include\ipv6
  asm define: MainProtocol=698
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\ETH1_NUC972.sct
  group Entry
    ./: ETH1_startup.s ETH1_NUC972.sct
  group NUC97x
    ../NUC97x/: NUC97x_IO.c NUC97x_AIC.c NUC97x_MAC.c NUC97x_SoftDelay.c
  group Device
    ../Driver/: NUC97x_IP101GR.c
  group sys
    ../Driver/Source/: sys_nuc970.s system_nuc970.c standalone.c sys_uart.c sys_timer.c
  group main
    ./: ETH1_main.c net1API.c ETH1_Lable.c
  group LwIP
    ../OS/lwip-1.4.1/netif/: nuc970_eth0.c nuc970_eth1.c ethernetif.c
    ../OS/lwip-1.4.1/: sys_arch.c
  group LwIP_netif
    ../OS/ThirdParty/lwip-1.4.1/src/netif/: etharp.c slipif.c
  group LwIP_core
    ../OS/ThirdParty/lwip-1.4.1/src/core/: init.c def.c mem.c memp.c dhcp.c netif.c pbuf.c tcp.c tcp_in.c tcp_out.c udp.c timers.c sys.c dns.c raw.c stats.c
  group LwIP_core_ipv4
    ../OS/ThirdParty/lwip-1.4.1/src/core/ipv4/: icmp.c inet.c inet_chksum.c ip.c ip_addr.c ip_frag.c autoip.c igmp.c
  group LwIP_core_ipv6
    ../OS/ThirdParty/lwip-1.4.1/src/core/ipv6/: icmp6.c inet6.c ip6.c ip6_addr.c
  group LwIP_core_snmp
    ../OS/ThirdParty/lwip-1.4.1/src/core/snmp/: asn1_dec.c asn1_enc.c mib_structs.c mib2.c msg_in.c msg_out.c
  group LwIP_netif_ppp
    ../OS/ThirdParty/lwip-1.4.1/src/netif/ppp/: auth.c chap.c chpms.c fsm.c ipcp.c lcp.c magic.c md5.c pap.c ppp.c ppp_oe.c randm.c vj.c
  group LwIP_api
    ../OS/ThirdParty/lwip-1.4.1/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
