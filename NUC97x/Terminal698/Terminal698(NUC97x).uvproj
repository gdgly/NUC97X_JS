# Keil uVision project Terminal698(NUC97x).uvproj, settings and files
target 698.45 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Terminal698(NUC97x)
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\Terminal698(NUC97x).axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698
  c include: ..\..\STM32F4xx\H698
  asm define: MainProtocol=698
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\Terminal698_NUC97x.sct
  group Entry
    ../../STM32F4xx/Terminal698/: Terminal_Entry.s
    ./: Terminal698_NUC97x.sct linux-698.45.sct
  group LIB
    ../../STM32F4xx/MS/: Ethernet-NUC97x.c Ethernet-NUC97x-linux.c
    ../TEST/: LOG.c
    ../../lib(20200522)/江苏调试/: NUC97xLIB_698.lib
    ../../lib(20200522)/江苏正式/: NUC97xLIB_698正式.lib
  group Display
    ../../STM32F4xx/Display/: Display.c DisplayLoop_ICO.c DisplayError.c DisplayFlash.c DisplayFTP.c DisplayLoop.c DisplayLoop_ACSample.c DisplayLoop_Info.c DisplayLoop_Self.c DisplayLoop_Warning.c Draw.c Warning.c
    ../../STM32F4xx/DL698/: DL698_DisplayLoop_Contrl.c
  group Calculate
    ../../STM32F4xx/Calculate/: Calculate.c ASMCalculate.c DataConversion.c ascii.c
  group extern_MRW
    ../Driver/: extern_MRW.c
  group Main
    ../../STM32F4xx/Terminal698/: Terminal_Main.c Terminal_Init.c Terminal_VER.c Terminal_ISR.c Terminal_Timer.c Terminal_PowerDown.c
    ../../STM32F4xx/MS/: SetInit.c MS_ISR_ASM.c
    ../../STM32F4xx/TEST/: Test_RAM.c
  group GPRS
    ../../STM32F4xx/Device/: ATNo.h GPRS_3763.c GPRS_SMS_RxTx.c GPRS_FTP_RxTx.c GPRS_3763_back.c
    ../../STM32F4xx/Terminal698/: ATString.c
  group UART Manage
    ../../STM32F4xx/Terminal698/: Terminal698_Uart_Manage.c UartAuto_645.c Terminal_ReadMeter_ACSample.c
  group DL698_UART
    ../../STM32F4xx/DL698/: DL698_DataDef.c DL698_OI_IC.c DL698_TESAM.c DL698_UART.cpp DL698_LINK.cpp DL698_CONNECT.cpp DL698_ConnectAppOI.c DL698_SECURITY.c DL698_TIMETAG.c DL698_GET.cpp DL698_GET_iMeterLIB.c DL698_GET_iMeter.c DL698_DATALIB.c DL698_DATALIB_2000.c DL698_GET_EVENT.cpp DL698_GET_4100.c DL698_GET_6000.cpp DL698_GET_F000.cpp DL698_GET_RECORD.c DL698_SETLIB.c DL698_SETLIB_2000.c DL698_SETLIB_EVENT.c DL698_SETLIB_4000.c DL698_SETLIB_5000.c DL698_SETLIB_6000.c DL698_SETLIB_8000.c DL698_SETLIB_F000.c DL698_SET.cpp DL698_SET_EVENT.cpp DL698_SET_6000.cpp DL698_ACTION.cpp DL698_ACTION_EVENT.cpp DL698_ACTION_4000.cpp DL698_ACTION_5000.c DL698_ACTION_6000.cpp DL698_ACTION_8000.cpp DL698_ACTION_F000.cpp DL698_GET_SET_ACTION_2000.c DL698_PROXY.c DL698_REPORT.c DL698_FILE.c DL698_FactoryTest.c cJSON.c DL698_JSON.c DL698_ACTION_4000.c
  group INIT_USER0
    ../../STM32F4xx/DL698/: DL698_SETInit_USER0xx.c DL698_SETInit_Event_USER0xx.c DL698_SETInit_6000_Project2xx_USER0xx.c DL698_SETInit_6000_Project3xx_USER0xx.c
  group INIT_USER12xx
    ../../STM32F4xx/DL698/: DL698_SETInit_USER12xx.c DL698_SETInit_Event_USER12xx.c DL698_SETInit_6000_Project3xx_USER12xx.c
  group INIT_USER9xx
    ../../STM32F4xx/DL698/: DL698_SETInit_USER9xx.c DL698_SETInit_Event_USER9xx.c DL698_SETInit_6000_Project2xx_USER9xx.c
  group INIT_USER15xx
    ../../STM32F4xx/DL698/: DL698_SETInit_USER15xx.c DL698_SETInit_Event_USER15xx.c DL698_SETInit_6000_Project3xx_USER15xx.c
  group INIT_USER16xx
    ../../STM32F4xx/DL698/: DL698_SETInit_USER16xx.c DL698_SETInit_Event_USER16xx.c DL698_SETInit_6000_Project4xx_USER16xx.c
  group INIT_USER17xx
    ../../STM32F4xx/DL698/: DL698_SETInit_USER17xx.c DL698_SETInit_Event_USER17xx.c DL698_SETInit_6000_Project2xx_USER17xx.c
  group RM_TASK
    ../../STM32F4xx/DL698/: DL698_SETInit_601E.c TASK.cpp RM_TASK.cpp RM_TASK_USERxxx.c RM_RS485_Manage.cpp RM_RS485.c RM_3762_Manage.c RM_3762.c Uart_3762_RxTx.c RM_3762_RouterActive.c RM_3762_iActive.c RM_3762_iActive_HPLC.c Info_3762.c RM_TxDATA.c RM_TxDATA_DL1997.cpp RM_TxDATA_DL2007.cpp RM_TxDATA_DL698.cpp RM_TxDATA_Landis.c RM_RxDATA.cpp RM_TxDATA_ABB.c RM_RxDATA_DL1997.cpp RM_RxDATA_DL2007.cpp RM_RxDATA_DL698.cpp RM_RxDATA_ABB.c RM_RxDATA_Landis.c
  group OTHER_TASK
    ../../STM32F4xx/DL698/: PROXY_TASK.c BroadcastTime.c MeterAutoReport.c AutoSearchMeter_3762.c AutoSearchMeter_RS485.c
  group FILE
    ../../STM32F4xx/DL698/: RM_Record.cpp Get_RM_Record.c EVENT_Record.c CONGEAL_Record.c SearchMeter_Record.c MeterAutoReport_Record.c
  group EVENT
    ../../STM32F4xx/DL698/: EVENT_CALC.c EVENT_CALC_iMeter.c RM_Event_DL2007.c
  group DATA
    ../../STM32F4xx/DL698/: CALC_SwitchIn.c CALC_RESET_FLOW_TIME.c CALC_Voltage_Qualification_Rate.c CALC_impIn.c CALC_TAG.c
  group CONTRL
    ../../STM32F4xx/DL698/: Contrl_Manage.c Contrl_Uart.c Contrl_Remote.c Contrl_Power.c Contrl_Energy.c Contrl_Out.c Contrl_State.c
  group TEST
    ../../STM32F4xx/DL698/: DL698TEST_1.c DL698TEST_USER9xx.c
  group End
    ../../STM32F4xx/Terminal698/: Terminal_End.s
target linux-698.45 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Terminal698(NUC97x)
  AfterMake: E:\CHINT_WORK\Keil-5-22\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\Terminal698(NUC97x).axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698
  c include: ..\..\STM32F4xx\H698;..\Driver\Include
  asm define: MainProtocol=698
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\linux-698.45.sct
target linux-698.45TS (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Terminal698(NUC97x)
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698
  c include: ..\..\STM32F4xx\H698;..\Driver\Include
  asm define: MainProtocol=698
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\linux-698.45.sct
target linux-698.45zs (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Terminal698(NUC97x)
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698
  c include: ..\..\STM32F4xx\H698;..\Driver\Include
  asm define: MainProtocol=698
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\linux-698.45.sct
