# Keil uVision project Terminal376(NUC97x).uvproj, settings and files
target Target 1 (ARM-ADS)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Terminal376
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT9: RAM 0xf8002000 size 0x8000
