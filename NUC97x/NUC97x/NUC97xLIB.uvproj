# Keil uVision project NUC97xLIB.uvproj, settings and files
target 698.45 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: NUC97xLIB_698 (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698
  c include: ..\..\STM32F4xx\H698
  asm define: MainProtocol=698
  memory RVCT9: RAM 0xf8002000 size 0x8000
  group NUC97x
    ../Driver/Source/: sys_nuc970.s
    ./: system_nuc970.c NUC97x_IO.c NUC97x_RCC.c NUC97x_SoftDelay.c NUC97x_MAC.c NUC97x_WDG.c NUC97x_SPI.c NUC97x_CRC.c NUC97x_EBI.c NUC97x_TMR.c NUC97x_AIC.c NUC97x_UART.c NUC97x_DMA.c NUC97x_ADC.c NUC97x_RTC.c NUC97x_PWR.c NUC97x_EXTI.c NUC97x_PWM.c
  group Device
    ../../STM32F4xx/Device/: extern_MRW.c IO_I2C.c RTC.c 24AA02E48.c IC_BUZZ.c
    ../Driver/: NUC97x_SPIFLASH.c NUC97x_NAND.c NUC97x_IP101GR.c NUC97x_ATM90E36.c NUC97x_ATT7022.c TESAM.c Button.c
  group Calculate
    ../../STM32F4xx/Calculate/: ascii.c
  group OS
    ../OS/: OS.c OS_Event.c
    ../MS/: yaffsAPP.c
  group MS
    ../../STM32F4xx/MS/: MS.c Data_Save.c
  group ACTION
    ../../STM32F4xx/DL698/: DL698_DataDef.c
  group TEST
    ../TEST/: LOG.c TestReport.c Test_RAM.c
target 376.1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NUC97xLIB_376 (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=376
  asm define: MainProtocol=376
  memory RVCT9: RAM 0xf8002000 size 0x8000
target CSG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: NUC97xLIB_CSG (library)
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=CSG
  asm define: MainProtocol=645
  memory RVCT9: RAM 0xf8002000 size 0x8000
