# Keil uVision project Meter698(NUC97x).uvproj, settings and files
target 698.45 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Meter698(NUC97x)
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\Meter698(NUC97x).axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698
  c include: ..\..\STM32F4xx\H698;..\..\STM32F4xx\Head
  asm define: MainProtocol=698
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\Meter698_NUC97x.sct
  group Entry
    ../../STM32F4xx/Meter698/: Meter_Entry.s
    ./: Meter698_NUC97x.sct Meter376_NUC97x.sct MeterCSG_NUC97x.sct Meter698_linux.sct
  group LIB
    D:/obj/: NUC97xLIB_698.lib NUC97xLIB_376.lib NUC97xLIB_CSG.lib
  group Display
    ../../STM32F4xx/Meter698/: SEGDisplay.c Meter07_DisplayUSB.c Meter07_DisplayError.c Meter07_DisplayLoop.c
  group Calculate
    ../../STM32F4xx/Calculate/: Calculate.c
  group extern_MRW
    ../Driver/: extern_MRW.c
  group Device
    ../Driver/: NUC97x_ATM90E36.c NUC97x_ATT7022.c
  group Main
    ../../STM32F4xx/Meter698/: Meter_Main.c Meter_Init.c Meter_VER.c Meter_ISR.c Meter_Timer.c
    ../../STM32F4xx/MS/: SetInit.c
  group InitLib
    ../../STM32F4xx/Meter698/: I1_SetInitLib_Project2xx_USER0xx.c I1_SetInitLib_Project2xx_USER9xx.c I1_SetInitLib_Project2xx_USER17xx.c I1_SetInitLib_Project3xx_USER0xx.c I1_SetInitLib_Project3xx_USER12xx.c I1_SetInitLib_Project3xx_USER15xx.c I1_SetInitLib_Project4xx_USER16xx.c
    ../../STM32F4xx/Meter/: I1_SetInitLib_Project2xx_USER14xx.c I1_SetInitLib_Project2xx_USER30xx.c I1_SetInitLib_Project3xx_USER30xx.c I1_SetInitLib_Project3xx_USER34xx.c
  group UART
    ../../STM32F4xx/Meter698/: Meter_Uart_Manage.c Meter07_DL645.c Meter07_DL645_MESAM.c Meter07_Uart_Factory_90E36.c Meter07Lib1.c Meter07Lib2.c Meter07Lib_Sour.c Meter07Lib_Sour_Energy.c Meter07Lib_Sour_Demand.c Meter07Lib_Sour_Variable.c Meter07Lib_Sour_Parameter.c Meter07Lib_Sour_Congeal.c Meter07Lib_Sour_Event_Set.c Meter07Lib_Sour_Event1.c Meter07Lib_Sour_Event2.c Meter07Lib_Sour_Event3.c Meter07Lib_Sour_Extend.c Meter07Lib_DI.c Meter07Lib_Point.c Meter07Lib_SegLCD.c UartAuto_3761.c
    ./: Meter07_Uart_Factory_ATT7022E.c
  group Function
    ../../STM32F4xx/Meter698/: Meter07_Control.c Meter07_Variable.c Meter07_Measure_90E36.c Meter07_Energy_90E36.c Meter07_Demand.c Meter07_Congeal.c Meter07_Event.c Meter07_In.c Meter07_AutoRePort.c
    ./: Meter07_Measure_ATT7022E.c Meter07_Energy_ATT7022E.c
  group End
    ../../STM32F4xx/Meter698/: Meter_End.s
target 376.1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Meter376(NUC97x)
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\Meter376(NUC97x).axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=376
  c include: ..\..\STM32F4xx\H698;..\..\STM32F4xx\Head
  asm define: MainProtocol=376
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\Meter376_NUC97x.sct
target CSG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: MeterCSG(NUC97x)
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\MeterCSG(NUC97x).axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=CSG
  c include: ..\..\STM32F4xx\H698;..\..\STM32F4xx\Head
  asm define: MainProtocol=645
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\MeterCSG_NUC97x.sct
target linux_698.45 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Meter698(NUC97x)
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698
  c include: ..\..\STM32F4xx\H698;..\..\STM32F4xx\Head
  asm define: MainProtocol=698
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\Meter698_linux.sct
