# Keil uVision project Menu698(NUC97x).uvproj, settings and files
target 698.45 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: Menu698(NUC97x)
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\Menu698(NUC97x).axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698
  c include: ..\..\STM32F4xx\H698
  asm define: MainProtocol=698
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\Menu698_NUC97x.sct
  group Entry
    ../../STM32F4xx/Menu698/: Menu_Entry.s
    ./: Menu698_NUC97x.sct Menu698_linux.sct
  group LIB
    ../../STM32F4xx/DL698/: Get_RM_Record.c
    ../../lib(20200522)/江苏调试/: NUC97xLIB_698.lib
    ../../lib(20200522)/江苏正式/: NUC97xLIB_698正式.lib
  group Display
    ../../STM32F4xx/Display/: Display.c Draw.c
  group Calculate
    ../../STM32F4xx/Calculate/: Calculate.c DataConversion.c ascii.c
  group extern_MRW
    ../Driver/: extern_MRW.c
  group Main
    ../../STM32F4xx/Menu698/: Menu_Main.c Menu_Init.c Menu_VER.c
  group Menu
    ../../STM32F4xx/Menu698/: Menu.c Menu_1_RealTimeData.c Menu_2_Parameters.c Menu_2_ParametersSetting.c Menu_3_ControlState.c Menu_3_SystemManagement.c Menu_4_MeterData.c Menu_5_ChineseNews.c Menu_6_PowerPurchase .c Menu_7_TerminalInformation.c
  group End
    ../../STM32F4xx/Menu698/: Menu_End.s
target linux_698.45 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Menu698(NUC97x)
  AfterMake: E:\CHINT_WORK\Keil-5-22\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\Menu698(NUC97x).axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698
  c include: ..\..\STM32F4xx\H698
  asm define: MainProtocol=698
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\Menu698_linux.sct
target linux_698.45zs (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: Menu698(NUC97x)
  AfterMake: as above
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698
  c include: ..\..\STM32F4xx\H698
  asm define: MainProtocol=698
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\Menu698_linux.sct
