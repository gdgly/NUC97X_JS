# Keil uVision project TEST(NUC97x).uvproj, settings and files
target 698.45 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: IRAM(0xF8002000-0xF8009FFF) CLOCK(24000000) CPUTYPE(ARM926EJ-S)
  output: TEST698(NUC97x)
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\TEST698(NUC97x).axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=698,
  c include: ..\..\STM32F4xx\H698
  asm define: MainProtocol=698,
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\TEST698_NUC97x.sct
  group Entry
    ./: Test_Entry.s TEST376_NUC97x.sct TEST698_NUC97x.sct TESTcsg_NUC97x.sct
  group LIB
    D:/obj/: NUC97xLIB_698.lib NUC97xLIB_376.lib NUC97xLIB_CSG.lib
    ../NUC97x/: NUC97x_MAC.c
  group Display
    ../../STM32F4xx/Display/: Display.c Draw.c
  group Calculate
    ../../STM32F4xx/Calculate/: Calculate.c ascii.c
  group Menu
    ../../STM32F4xx/Menu698/: Menu.c
  group extern_MRW
    ../Driver/: extern_MRW.c
  group Main
    ./: Test_Main.c Test_Init.c Test_VER.c TestReport.c Test_ISR.c
  group TEST
    ./: Test.c Test_ALIGN698.c Test_RAM.c Test_NAND.c Test_YAFFS.c Test_FLASH_Block_Err.c Test_FLASH_Life.c Test_POWER.c Test_90E36.c Test_ATT7022.c Test_RTC.c Test_IP101.c Test_ETH.c Test_GPRS.c Test_LOCAL_MODULE.c Test_CONTRL_MODULE.c Test_UART.c Test_ESAM.c Test_INOUT.c Test_LOG.c Test_USB.c Test_off_destore_irq.c Test_FlushCache.c Test_GDMA.c
    ../../STM32F4xx/TEST/: Test_KEY_LED_BUZZER.c
  group 376.2
    ./: Test_Uart_3762_RxTx.c Test_ReadMeter_3762_376.c Test_ReadMeter_3762_698.c Test_ReadMeter_3762_CSG.c
  group End
    ./: Test_End.s
target 376.1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: TEST376(NUC97x)
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\TEST376(NUC97x).axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=376
  c include: ..\..\STM32F4xx\Head
  asm define: MainProtocol=376
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\TEST376_NUC97x.sct
target CSG (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: TMPA900CMXBG Toshiba
  cpu: as above
  output: TESTcsg(NUC97x)
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o D:\obj\BIN\ D:\obj\TESTcsg(NUC97x).axf
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MainProtocol=CSG
  c include: ..\..\STM32F4xx\Hcsg
  asm define: MainProtocol=645
  memory RVCT9: RAM 0xf8002000 size 0x8000
  scatter file: .\TESTcsg_NUC97x.sct
